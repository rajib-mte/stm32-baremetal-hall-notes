<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\13.0_Ultrasonic_sensor_HC-SR04_interface.ewp</path>
  </project>
  <batchBuild />
</workspace>
