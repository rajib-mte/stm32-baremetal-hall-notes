# Keil uVision project 11.3 SPI driver.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 11.3 SPI driver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: main.c seconde.c
  group library
    ./Library/: ST32F4_DELAY.c ST32F4_DELAY.h USART2.c USART2.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
