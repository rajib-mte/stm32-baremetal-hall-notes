# Keil uVision project USART Tx my 2nd code.uvprojx, settings and files
target STM32F401CCUX (6210000::V6.21::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USART Tx my 2nd code +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group Library
    ../../../Library/Delay/: DELAY.c DELAY.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
